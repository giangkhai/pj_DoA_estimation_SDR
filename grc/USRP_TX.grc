options:
  parameters:
    generate_options: qt_gui
    id: lab_005
    output_language: python
    title: Transmission QPSK  - USRP HW in the Loop
  states: {}

blocks:
- name: Ar
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: RX Gain (lin.)
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.71'
  states: {}
- name: As
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: TX Gain (lin.)
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.9'
  states: {}
- name: f0
  id: variable
  parameters:
    value: 446.00625e6
  states: {}
- name: fi
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: fi [Hz]
    start: '-10'
    step: '0.001'
    stop: '10'
    value: '0'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: label_f0
  id: variable_qtgui_label
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: Carrier Freq. (f0) [Hz]
    type: real
    value: f0
  states: {}
- name: label_fs
  id: variable_qtgui_label
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: Sample Freq. (fs) [Hz]
    type: real
    value: fs
  states: {}
- name: sample_num
  id: variable
  parameters:
    value: '100'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/administrateur/Téléchargements/part1.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/administrateur/Téléchargements/part2.dat
    repeat: 'True'
    type: complex
  states: {}
- name: import_2
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0, 0, 1,1
    label0: RF Options
    num_tabs: '1'
  states: {}
- name: qtgui_tab_widget_rx1
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,3,2,2
    label0: RX1- Time
    label1: RX1 - Frequency
    num_tabs: '2'
  states: {}
- name: qtgui_tab_widget_rx2
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,5,2,2
    label0: RX2 -  Time
    label1: RX2 - Frequency
    num_tabs: '2'
  states: {}
- name: qtgui_tab_widget_tx
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,1,2,2
    label0: TX - Time
    label1: TX - Frequency
    num_tabs: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: fs
    center_freq0: f0
    clock_rate: '0.0'
    dev_addr: serial=30E8A57
    dev_args: '""'
    gain0: As
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: fs
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: fs
    center_freq0: f0
    clock_rate: '0.0'
    dev_addr: serial=31150EC
    dev_args: '""'
    gain0: As
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: fs
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_0_0, '0', uhd_usrp_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
