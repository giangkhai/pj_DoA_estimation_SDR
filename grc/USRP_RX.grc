options:
  parameters:
    generate_options: qt_gui
    id: lab_005
    output_language: python
    title: Transmission QPSK  - USRP HW in the Loop
  states: {}

blocks:
- name: Ar
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: RX Gain (lin.)
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: As
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: TX Gain (lin.)
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: f0
  id: variable
  parameters:
    value: 446.00625e6
  states: {}
- name: fi
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: fi [Hz]
    start: '-10'
    step: '0.001'
    stop: '10'
    value: '0'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: label_f0
  id: variable_qtgui_label
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: Carrier Freq. (f0) [Hz]
    type: real
    value: f0
  states: {}
- name: label_fs
  id: variable_qtgui_label
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: Sample Freq. (fs) [Hz]
    type: real
    value: fs
  states: {}
- name: sample_num
  id: variable
  parameters:
    value: '100'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/administrateur/Téléchargements/experiment/rx1_2.dat
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/administrateur/Téléchargements/experiment/rx2_2.dat
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: import_2
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0, 0, 1,1
    label0: RF Options
    num_tabs: '1'
  states: {}
- name: qtgui_tab_widget_rx1
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,3,2,2
    label0: RX1- Time
    label1: RX1 - Frequency
    num_tabs: '2'
  states: {}
- name: qtgui_tab_widget_rx2
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,5,2,2
    label0: RX2 -  Time
    label1: RX2 - Frequency
    num_tabs: '2'
  states: {}
- name: qtgui_tab_widget_tx
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,1,2,2
    label0: TX - Time
    label1: TX - Frequency
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: qtgui_tab_widget_rx1@0:0,0,1,4
    label1: In-Phase
    label2: Quadrature
    name: RX1 - Signal x(t)
    size: '300'
    srate: fs
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: qtgui_tab_widget_rx2@0:0,0,1,4
    label1: In-Phase
    label2: Quadrature
    name: RX2 - Signal y(t)
    size: '300'
    srate: fs
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: In-Phase
    name: Phase difference arg[x(t) y*(t)]
    size: '3000'
    srate: fs
    type: float
    ymax: pi
    ymin: '-pi'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: f0
    center_freq1: f0
    clock_rate: '0.0'
    dev_addr: serial=3394EE7
    dev_args: '""'
    gain0: Ar
    gain1: Ar
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: fs
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_conjugate_cc_0, '1']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
